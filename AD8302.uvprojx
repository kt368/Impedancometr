# Keil uVision project AD8302.uvprojx, settings and files
target LPC1758 (ARM-ADS)
  device: LPC1758 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AD8302
  c flags: Optim=1
  c define: LPC17XX
  c include: .\include;.\include\drivers;.\include\LPC17XX;.\include\protothreads
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./source/: startup_LPC17xx.s
  group CMSIS-CM3
    ./source/: system_LPC17xx.c
  group Drivers
    ./source/drivers/: lpc17xx_pinsel.c lpc17xx_spi.c lpc17xx_uart.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_clkpwr.c lpc17xx_timer.c
    ./source/AD7793/: AD7793.c Communication.c
  group Source
    ./source/: main.c Init.c System.c AD9833.c Calibrating.c Measuring.c Flash_save_read.c
  group UART
    ./source/: Serial.c SW_FIFO.c Getline.c Retarget.c
software components: CMSIS:CORE 4.1.0
