# Keil uVision project AD8302.uvproj, settings and files
target LPC1758 (ARM-ADS)
  device: LPC1758 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: AD8302
  c flags: Optim=1
  c define: LPC17XX
  c include: .\include;.\include\drivers;.\include\LPC17XX;.\include\protothreads
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x10000500 size 0x7cfc
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./source/: startup_LPC17xx.s
  group CMSIS-CM3
    ./source/: system_LPC17xx.c
  group Drivers
    ./source/drivers/: lpc17xx_pinsel.c lpc17xx_spi.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c lpc17xx_adc.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_i2s.c
  group Source
    ./source/: Flash_save_read.c main.c Init.c System.c ProtoThreads.c Interrupts_handlers.c AD9833.c Power_management.c ADC.c
  group UART
    ./source/: Serial.c Retarget.c SW_FIFO.c Getline.c
